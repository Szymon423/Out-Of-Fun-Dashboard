# Use the weston.ini from this layer instead of the one from openembedded-core.
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
