FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://backlight.cfg"
