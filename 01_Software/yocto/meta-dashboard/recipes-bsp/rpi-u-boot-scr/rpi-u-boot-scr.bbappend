# boot.cmd.in with A/B slot selection for RAUC instead of meta-raspberrypi's (docs/ota-rauc.md).
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
