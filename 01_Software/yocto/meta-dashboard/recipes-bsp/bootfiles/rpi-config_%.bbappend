# Raspberry Pi Touch Display 2 (7") on the DSI port. Pi 4 does not detect it on its own.
RPI_EXTRA_CONFIG = "\n# Raspberry Pi Touch Display 2 (7 inch)\ndtoverlay=vc4-kms-dsi-ili9881-7inch\n"
